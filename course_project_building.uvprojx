# Keil uVision project course_project_building.uvprojx, settings and files
target course_project_building (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: course_project_building
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: ..\..\..\software\keil5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include;USER;Libraries\CMSIS\CM3\CoreSupport;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;Libraries\STM32F10x_StdPeriph_Driver\inc;Libraries\STM32F10x_StdPeriph_Driver\src;RTE\_Target 1;USER\led;.eide\deps
  asm define: STM32F10X_MD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    USER/: main.c
  group Source Group 1/USER/usart
    USER/usart/: usart.c usart.h
  group Source Group 1/USER/TimBase
    USER/TimBase/: bsp_TiMbase.c bsp_TiMbase.h
  group Source Group 1/USER/SysTick
    USER/SysTick/: bsp_SysTick.c bsp_SysTick.h
  group Source Group 1/USER/sys
    USER/sys/: sys.c sys.h
  group Source Group 1/USER/oled
    USER/oled/: bmp.h oled.c oled.h oledfont.h
  group Source Group 1/USER/IIC_Hardware
    USER/IIC_Hardware/: IIC_Hardware.c IIC_Hardware.h
  group Source Group 1/USER/HCSR04
    USER/HCSR04/: hcsr.c hcsr.h
  group Source Group 1/USER/EXIT
    USER/EXIT/: bsp_exti.c bsp_exti.h
  group Source Group 1/USER/delay
    USER/delay/: delay.c delay.h
  group Source Group 1/startup
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Source Group 1/src
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Source Group 1/LIB
    .pack/Keil/STM32F1xx_DFP.2.2.0/Device/Include/: stm32f10x.h system_stm32f10x.h
    Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    Libraries/: stdio.h
    USER/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c
  group Source Group 1/inc
    Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
